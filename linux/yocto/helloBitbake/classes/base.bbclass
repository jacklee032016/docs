addtask build


